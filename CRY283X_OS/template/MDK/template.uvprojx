# Keil uVision project template.uvprojx, settings and files
target template_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003C0) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CC_ARM,__DEBUG,HC32F460,USE_DEVICE_DRIVER_LIB,NDEBUG,USE_RT_THREAD
  c misc: --diag_suppress=186,66,188
  c include: ..\..\mcu\common;..\source;..\..\driver\inc;..\source\rt-thread\bsp;..\source\rt-thread\include\libc;..\source\rt-thread\include;..\source\rt-thread\components\finsh;..\source\lvgl\examples\porting;..\source\lvgl\src\core;..\source\lvgl\src\draw;..\source\lvgl\src\font;..\source\lvgl\src\hal;..\source\lvgl\src\misc;..\source\lvgl\src\widgets;..\source\lvgl\src\extra;..\source\lvgl\src\extra\layouts;..\source\lvgl\src\extra\others;..\source\lvgl\src\extra\themes;..\source\lvgl\src\extra\widgets;..\source\lvgl\src\extra\libs;..\source\peripheral;..\source\sd_card\inc;..\source\lvgl\rt-thread;..\source\dsp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f460.s
    ../../mcu/common/: system_hc32f460.c
  group source
    ../source/: main.c
    ../source/rt-thread/bsp/: board.c rtconfig.h
  group driver
    ../../driver/src/: hc32f460_icg.c hc32f460_utility.c hc32f460_gpio.c hc32f460_usart.c hc32f460_pwc.c hc32f460_clk.c hc32f460_efm.c hc32f460_sram.c hc32f460_interrupts.c hc32f460_dmac.c hc32f460_i2c.c hc32f460_spi.c hc32f460_i2s.c hc32f460_adc.c hc32f460_timer6.c hc32f460_sdioc.c hc32f460_rtc.c hc32f460_timer4_cnt.c hc32f460_cmp.c hc32f460_qspi.c
  group Readme
    ../: Readme.txt
  group rtt/port
    ../source/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group rtt/source
    ../source/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group finsh
    ../source/rt-thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group lv_porting
    ../source/lvgl/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lv_extra
    ../source/lvgl/src/extra/: lv_extra.c
    ../source/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../source/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../source/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../source/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../source/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../source/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../source/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../source/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../source/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../source/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../source/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../source/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../source/lvgl/src/extra/widgets/led/: lv_led.c
    ../source/lvgl/src/extra/widgets/list/: lv_list.c
    ../source/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../source/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../source/lvgl/src/extra/widgets/span/: lv_span.c
    ../source/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../source/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../source/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../source/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../source/lvgl/src/extra/widgets/win/: lv_win.c
  group lv_src
    ../source/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../source/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../source/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_14.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../source/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../source/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../source/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lv_libs
    ../source/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../source/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
  group peripheral
    ../source/peripheral/: cry_adc.c cry_flash.c cry_i2c_adc_dac_rtc_power.c cry_i2s_adc.c cry_lcd.c cry_pwm.c cry_qspi_flash.c cry_rtc.c cry_sdcard.c cry_spi_flash.c cry_usart.c
  group sd_card
    ../source/sd_card/src/: sd_card.c sdmmc_cmd.c
  group dsp
    E:/Ming/Keil/HC32/模板/CRY283X_OS/template/source/dsp/: cry283x_hc32_dsp_demolib.lib
target template_Release (ARM-ADS)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.2
  cpu: IROM(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F460,USE_DEVICE_DRIVER_LIB
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.1
